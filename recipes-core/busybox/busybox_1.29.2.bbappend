FILES_${PN} += "${base_libdir}/systemd/system/busybox-klogd.service \
                ${base_libdir}/systemd/system/multi-user.target.wants \
                ${base_libdir}/systemd/system/multi-user.target.wants/busybox-syslog.service"
