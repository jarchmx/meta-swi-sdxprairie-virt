inherit qprebuilt-setup
