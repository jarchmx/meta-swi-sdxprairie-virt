#do_package_qa[noexec] = "1"
FILES_${PN} += "/lighttpd.conf \
                /openssl.cnf"
