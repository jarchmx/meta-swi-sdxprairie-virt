#
#STAGING_KERNEL_DIR = "${WORKDIR}/kernel-source"

#STAGING_KERNEL_BUILDDIR = "${WORKDIR}/kernel-build-artifacts"
