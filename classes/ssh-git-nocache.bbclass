#Ignore local sstate
#do_populate_sysroot_setscene[noexec] = "0"
#do_package_write_rpm_setscene[noexec] = "0"
#do_deploy_setscene[noexec] = "0"
#do_package_qa_setscene[noexec] = "0"
#do_package_setscene[noexec] = "0"
#do_packagedata_setscene[noexec] = "0"
#do_populate_lic_setscene[noexec] = "0"

#do_populate_sysroot[nostamp] = "1"
SSTATE_MIRRORS = ""
